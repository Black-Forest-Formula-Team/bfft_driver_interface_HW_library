# Keil uVision project Project.uvprojx, settings and files
target STM32H745-Discovery (6120000::V6.12::.\ARMCLANG)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: EmbeddedWizard-STM32H745-Discovery +hex
  c flags: Optim=3 OneElfS=1 v6Lang=4 wLevel=3
  c define: USE_HAL_DRIVER STM32H745xx CORE_CM7 USE_STM32H745I_DISCO EW_USE_FREE_RTOS=1 EW_USE_EXTERNAL_FLASH=1 EW_BITMAP_PIXEL_SECTION_NAME=.SectionEwResource EW_FONT_PIXEL_SECTION_NAME=.SectionEwResource
  c include: ../Inc;..\..\..\ThirdParty\STM32Cube_FW_H7\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\..\ThirdParty\STM32Cube_FW_H7/Drivers/BSP/STM32H745I-DISCO;..\..\..\ThirdParty\STM32Cube_FW_H7/Drivers/BSP/Components;..\..\..\ThirdParty\STM32Cube_FW_H7\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\..\ThirdParty\STM32Cube_FW_H7\Drivers/CMSIS/Include;..\..\..\TargetSpecific\Drivers;..\..\..\TargetSpecific;..\..\GeneratedCode;..\..\Source;..\..\..\ThirdParty\STM32Cube_FW_H7\MiddleWares\Third_Party\FreeRTOS\Source\include;..\..\..\ThirdParty\STM32Cube_FW_H7\MiddleWares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\ThirdParty\STM32Cube_FW_H7\MiddleWares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM7\r0p1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x100000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32H745I-DISCO
    ../../../ThirdParty/STM32Cube_FW_H7/Drivers/BSP/STM32H745I-DISCO/: stm32h745i_discovery_sdram.c stm32h745i_discovery.c stm32h745i_discovery_qspi.c stm32h745i_discovery_bus.c
    ../../../ThirdParty/STM32Cube_FW_H7/Drivers/BSP/Components/mt48lc4m32b2/: mt48lc4m32b2.c
    ../../../ThirdParty/STM32Cube_FW_H7/Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../ThirdParty/STM32Cube_FW_H7/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_flash.c stm32h7xx_hal_i2c.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_ll_fmc.c stm32h7xx_hal_cortex.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_sdram.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal.c stm32h7xx_hal_pwr.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_mdma.c stm32h7xx_hal_exti.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_dma.c
  group EmWi/TargetSpecific
    ../../../TargetSpecific/: ew_bsp_graphics.c ew_bsp_clock.c ew_bsp_display.c ew_bsp_event.c ew_bsp_inout.c ew_bsp_console.c ew_bsp_system.c ew_bsp_touch.c stm32h7xx_it.c system_stm32h7xx.c
    ../../../TargetSpecific/Drivers/: ft5336.c ft5336_reg.c
  group EmWi/Application
    ./: startup_stm32h745xx.s
    ../../Source/: main.c DeviceDriver.c ewmain.c ewconfig.h
  group FreeRTOS
    ../../../ThirdParty/STM32Cube_FW_H7/MiddleWares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../ThirdParty/STM32Cube_FW_H7/MiddleWares/Third_Party/FreeRTOS/Source/: timers.c tasks.c queue.c list.c
    ../../../ThirdParty/STM32Cube_FW_H7/MiddleWares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../ThirdParty/STM32Cube_FW_H7/MiddleWares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1/: port.c
software components: Graphics:Embedded Wizard:New Project... 1.0.0
